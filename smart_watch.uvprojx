# Keil uVision project smart_watch.uvprojx, settings and files
target application (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smart_watch
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: NRF52 SOFTDEVICE_PRESENT BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_58 NRF52_PAN_55 NRF52_PAN_54 NRF52_PAN_31 NRF52_PAN_30 NRF52_PAN_51 NRF52_PAN_36 NRF52_PAN_53 S132 CONFIG_GPIO_AS_PINRESET BLE_STACK_SUPPORT_REQD SWI_DISABLE0 NRF52_PAN_20 NRF52_PAN_64 NRF52_PAN_62 NRF52_PAN_63 ARM_MATH_CM4 __HEAP_SIZE=512 FREERTOS
  c include: .\config;.\gfx;.\hardware;.\app;.\ble;.\lib;.\nanopb;.\gfx\fonts;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_advertising;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_bas;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_dis;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_nus;.\nRF5_SDK_11.0.0_89a8197\components\ble\common;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager\config;.\nRF5_SDK_11.0.0_89a8197\components\device;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\clock;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\common;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\config;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\delay;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\gpiote;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\ppi;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pstorage;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\saadc;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\spi_master;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\timer;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\twi_master;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\uart;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\wdt;.\nRF5_SDK_11.0.0_89a8197\components\libraries\button;.\nRF5_SDK_11.0.0_89a8197\components\libraries\experimental_section_vars;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fifo;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage\config;.\nRF5_SDK_11.0.0_89a8197\components\libraries\pwm;.\nRF5_SDK_11.0.0_89a8197\components\libraries\scheduler;.\nRF5_SDK_11.0.0_89a8197\components\libraries\timer;.\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\nRF5_SDK_11.0.0_89a8197\components\libraries\uart;.\nRF5_SDK_11.0.0_89a8197\components\libraries\util;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\common\softdevice_handler;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\s132\headers;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\s132\headers\nrf52;.\nRF5_SDK_11.0.0_89a8197\components\toolchain;.\nRF5_SDK_11.0.0_89a8197\external\freertos\config;.\nRF5_SDK_11.0.0_89a8197\external\freertos\portable\ARM\nrf52;.\nRF5_SDK_11.0.0_89a8197\external\freertos\portable\CMSIS\nrf52;.\nRF5_SDK_11.0.0_89a8197\external\freertos\source\include
  asm define: NRF52 SOFTDEVICE_PRESENT BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_58 NRF52_PAN_55 NRF52_PAN_54 NRF52_PAN_31 NRF52_PAN_30 NRF52_PAN_51 NRF52_PAN_36 NRF52_PAN_53 S132 CONFIG_GPIO_AS_PINRESET BLE_STACK_SUPPORT_REQD SWI_DISABLE0 NRF52_PAN_20 NRF52_PAN_64 NRF52_PAN_62 NRF52_PAN_63 __HEAP_SIZE=512 ARM_MATH_CM4 __HEAP_SIZE=512 FREERTOS
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group ble
    ./ble/: ble.c ble_protocol.c ble_watch_service.c
  group gfx
    ./gfx/: icon_data.c icons.c nrf_gfx.c weather_data.c
    ./gfx/fonts/: 7seg28.c 7seg32.c 7seg36.c m1c_10.c m1c_10b.c m1c_10t.c m1c_12.c m1c_12b.c m1c_12t.c m1c_14.c m1c_14b.c m1c_14t.c m1c_16.c m1c_16b.c m1c_18.c m1c_18b.c m1c_24b.c m1mn_28.c m1mn_32.c m1mn_36.c m1mn_48.c orkney8pts.c orkney24pts.c
  group hardware
    ./hardware/: accel.c backlight.c battery.c buttons.c hrm.c lcd.c pah8002.c vibration.c
  group lib
    ./lib/: utf8proc.c
  group nanopb
    ./nanopb/: pb_common.c pb_decode.c pb_encode.c smaq2oss.pb.c
  group Application
    ./: main.c
  group nRF_Libraries
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/button/: app_button.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/timer/: app_timer_appsh.c app_timer_freertos.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/fifo/: app_fifo.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/fstorage/: fstorage.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/uart/: retarget.c app_uart_fifo.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/pwm/: app_pwm.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/scheduler/: app_scheduler.c
  group nRF_BLE
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_advertising/: ble_advertising.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_services/ble_nus/: ble_nus.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/common/: ble_conn_params.c ble_srv_common.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_services/ble_bas/: ble_bas.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/delay/: nrf_delay.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/common/: nrf_drv_common.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/pstorage/: pstorage.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/timer/: nrf_drv_timer.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Softdevice
    ./nRF5_SDK_11.0.0_89a8197/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group freertos
    ./nRF5_SDK_11.0.0_89a8197/external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./nRF5_SDK_11.0.0_89a8197/external/freertos/source/portable/MemMang/: heap_2.c
    ./nRF5_SDK_11.0.0_89a8197/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ./nRF5_SDK_11.0.0_89a8197/external/freertos/portable/ARM/nrf52/: port.c
  group app
    ./app/: app_battery.c app_call.c app_hrm.c app_menu.c app_music.c app_time.c app_weather.c applets.c screen_mgr.c status.c tetris.c watchface.c weather.c
target flash_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
target package_dfu (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: as above
  output: smart_watch +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: "C:\Program Files (x86)\Nordic Semiconductor\nRFgo Studio\nrfutil.exe" dfu genpkg --application @L.bin --application-version 0xffffffff --dev-revision 0xffff --dev-type 0xffff --sd-req 136  "$Papp_dfu_package.zip"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: as above
  c include: as above
  asm define: as above
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.16.0
